# Keil uVision project FOC_Fortior_FU6832.uvproj, settings and files
target FOC_Fortior_FU6832 (MCS-51)
  device: FU6832 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FOC_Fortior_FU6832 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FU68xx_Hardware_Driver\Include;..\User\include
  asm include: ..\FU68xx_Hardware_Driver\Include;..\User\include
  link misc: REMOVEUNUSED
  group Application
    ../User/source/Application/: AddFunction.c Interrupt.c main.c
    ../User/include/: Customer.h Protect.h Develop.h
  group Function
    ../User/source/Function/: FocControl.c FocControlFunction.c MotorProtect.c BEMFDetect.c PLLInitandStateSwitch.c PLLFunction.LIB
  group Hardware
    ../User/source/Hardware/: ADC.c AMP.c CMP.c Driver.c GPIO.c PI.c Timer.c WDT.c UART.c
  group FU68xx_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: STARTUP_FU6804.A51
