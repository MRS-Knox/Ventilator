# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F446xx,USE_STDPERIPH_DRIVER
  c include: ..\2.Middle;..\3.Driver;..\4.Common;..\6.Library\inc;..\7.CMSIS;..\9.Start_Up;..\9.Start_Up;..\10.FreeRTOS\Source\include;..\10.FreeRTOS;..\10.FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\10.FreeRTOS\Source\portable\MemMang;..\10.FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../1.Application/: Application_Main.c
  group Middle
    ../2.Middle/: Middle_Blower.c Middle_ControlBlower.c Middle_Pressure.c
  group Driver
    ../3.Driver/: Driver_RGB.c Driver_Blower.c Driver_Pressure.c
  group Common
    ../4.Common/: Add_Function.c Use_Struct.c Use_Struct.h Use_Enum.h FreeRTOS_Define.h
  group FreeRTOS
    ../10.FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../10.FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../10.FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Library
    ../6.Library/inc/: FreeRTOSConfig.h
    ../6.Library/src/: stm32f4xx_it.c misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c systick.c
  group CMSIS
    ../7.CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Start_Up
    ../9.Start_Up/: startup_stm32f446xx.s
